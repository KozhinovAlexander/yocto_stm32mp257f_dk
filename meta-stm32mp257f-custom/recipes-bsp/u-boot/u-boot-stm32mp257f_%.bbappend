# Board-specific U-Boot extensions for STM32MP257F-DK
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Uncomment to add a custom U-Boot patch or environment file:
# SRC_URI += "file://0001-stm32mp257f-dk-custom-env.patch"
